# Keil uVision project BH-F103.uvprojx, settings and files
target 步进电机_TMC5160 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 步进电机_TMC5160 +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Led;..\..\User\AdvanceTim;..\..\Hardware\KEY;..\..\Hardware\TIMER;..\..\Hardware\TMC5160;..\..\Hardware\IO_control;..\..\Hardware\OLED;..\..\Hardware\Delay;..\..\Hardware\TLE5012B;..\..\Hardware\MODBUS;..\..\Hardware\pid;..\..\Test\protocol;..\..\Test\usart;..\..\Test\stepper
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h Config.h
    ../../User/Led/: bsp_led.c
  group HARDWARE
    ../../Hardware/KEY/: bsp_key.c
    ../../Hardware/TIMER/: bsp_timer.c
    ../../Hardware/TMC5160/: TMC5160.C Init_Program_Tabl.c
    ../../Hardware/IO_control/: IO_control.c
    ../../Hardware/OLED/: oled.c
    ../../Hardware/Delay/: Delay.c
    ../../Hardware/TLE5012B/: TLE5012B.C
    ../../Hardware/MODBUS/: modbus.c
    ../../Hardware/pid/: bsp_pid.c
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group DOC
    ../../Doc/: readme.txt
  group TEST
    ../../Test/protocol/: protocol.c
    ../../Test/usart/: bsp_debug_usart.c
    ../../Test/stepper/: bsp_stepper_ctrl.c
