# Keil uVision project GY200A_TM.uvprojx, settings and files
target GY200A_TM (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F105VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GY200A_TM +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER
  c include: ..\Library\CMSIS;..\Library\FWlib\inc;..\User;..\Library\CMSIS\startup;..\Hardware\oled;..\Hardware;..\Hardware\delay;..\Hardware\time;..\Hardware\gpio;..\Hardware\pid;..\Hardware\exti;..\Hardware\zam6228;..\Hardware\485;..\Hardware\watchdog;..\Hardware\tim7;..\Hardware\user_lib;..\Hardware\AT24C64
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Library/CMSIS/startup/: startup_stm32f10x_cl.s
  group Library
    ../Library/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/: main.c stm32f10x_it.c
    ../Library/CMSIS/: core_cm3.c system_stm32f10x.c
  group Hardware
    ../Hardware/oled/: i2c.c iic_ssd1306.c
    ../Hardware/delay/: delay.c
    ../Hardware/time/: timer.c
    ../Hardware/gpio/: gpio.c
    ../Hardware/pid/: pid.c
    ../Hardware/exti/: exti.c
    ../Hardware/zam6228/: gpio_i2c.c zam6228.c
    ../Hardware/485/: mbslave.c usart.c
    ../Hardware/watchdog/: wdg.c
    ../Hardware/tim7/: tim.c
    ../Hardware/user_lib/: user_lib.c
    ../Hardware/AT24C64/: bsp_eeprom_24xx.c bsp_i2c_gpio.c
